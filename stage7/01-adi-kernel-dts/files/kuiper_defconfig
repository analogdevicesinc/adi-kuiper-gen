## stage7/01-adi-kernel-dts/files/kuiper_defconfig
```kconfig
CONFIG_FUSE_FS=y
CONFIG_NAMESPACES=y
CONFIG_UTS_NS=y
CONFIG_IPC_NS=y
CONFIG_PID_NS=y
CONFIG_USER_NS=y
CONFIG_SECCOMP=y
```
