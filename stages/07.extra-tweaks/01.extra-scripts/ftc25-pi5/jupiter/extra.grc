options:
  parameters:
    generate_options: qt_gui
    id: doppler_radar_jupiter
    output_language: python
    title: doppler_radar_jupiter
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: decimation_1
  id: variable
  parameters:
    value: '40'
  states: {}
- name: decimation_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gain_control_mode_rx0
  id: variable
  parameters:
    value: '''spi'''
  states: {}
- name: hardwaregain_rx0
  id: variable_qtgui_range
  parameters:
    label: Rx Gain [dBfs]
    start: '0'
    step: '1'
    stop: '34'
    value: '20'
  states: {}
- name: hardwaregain_tx0
  id: variable_qtgui_range
  parameters:
    label: Tx Attenuation [dBfs]
    start: '-41'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: interval_update
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: jupiter_ip
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:<TODO:jupiter_ip>
    writeback: None
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: int(150000)
  states: {}
- name: rx_lo_freq
  id: variable
  parameters:
    value: int(5674000000)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: transmit_sine_freq
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: int(5674000000)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: transmit_sine_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: decimation_1
    gain: '1'
    high_cutoff_freq: transmit_sine_freq + 300
    low_cutoff_freq: transmit_sine_freq - 300
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: transmit_sine_freq + 20
    low_cutoff_freq: transmit_sine_freq - 20
    samp_rate: samp_rate/decimation_1/decimation_2
    type: fir_filter_ccf
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_imag_0_4_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_4_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0_0_4_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_5_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage2
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    channel: adrv9002-phy
    device: adrv9002-phy
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(hardwaregain_rx0)
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(0)
  states: {}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(-40)
  states: {}
- name: iio_attr_updater_0_1
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(hardwaregain_tx0)
  states: {}
- name: iio_attr_updater_0_1_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(rx_lo_freq)
  states: {}
- name: iio_attr_updater_0_1_0_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(tx_lo_freq)
  states: {}
- name: iio_attr_updater_0_1_0_0_0
  id: iio_attr_updater
  parameters:
    attr: initial_calibrations
    interval: interval_update
    value: '''auto'''
  states: {}
- name: iio_attr_updater_0_1_0_1
  id: iio_attr_updater
  parameters:
    attr: gain_control_mode
    interval: interval_update
    value: gain_control_mode_rx0
  states: {}
- name: iio_device_sink_0_1
  id: iio_device_sink
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0'',''voltage1'']'
    cyclic: 'False'
    device: axi-adrv9002-tx-lpc
    device_phy: adrv9002-phy
    interpolation: '1'
    params: '[]'
    uri: jupiter_ip
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0_i'',''voltage0_q'']'
    decimation: '1'
    device: axi-adrv9002-rx-lpc
    device_phy: adrv9002-phy
    params: '[]'
    uri: jupiter_ip
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: (0,1,1,1)
    label1: Rx Raw
    name: Frequency Spectrum Rx Raw
    type: complex
    ymin: '-240'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation_1
    fc: '0'
    fftsize: '8192'
    gui_hint: (1,1,1,1)
    label1: Rx BPF
    name: Frequency Spectrum Rx BPF
    type: complex
    ymin: '-240'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation_1/decimation_2
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    gui_hint: (2,1,1,1)
    name: Frequency Spectrum Rx BRF
    type: complex
    ymin: '-240'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,0,1,1)
    label1: Rx Raw Re
    label2: Rx Raw Im
    name: Time Domain Rx Raw
    size: 1024*2*2
    srate: samp_rate
    type: complex
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,1)
    label1: Rx BPF Re
    label2: Rx BPF Im
    name: Time domain Rx BPF
    size: 1024*2*2
    srate: samp_rate/decimation_1
    type: complex
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (2,0,1,1)
    label1: Rx BRF Re
    label2: Rx BRF Im
    name: Time Domain BRF
    size: 1024*2*2
    srate: samp_rate/decimation_1/decimation_2
    type: complex
    ymax: '0.01'
    ymin: '-0.01'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_imag_0_4_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0_4_0, '0']
- [band_pass_filter_0, '0', band_reject_filter_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [band_reject_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_reject_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [band_reject_filter_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_imag_0_4_0, '0', blocks_float_to_short_0_0_4_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0_4_0, '0', blocks_float_to_short_0_5_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_short_0_0_4_0, '0', iio_device_sink_0_1, '1']
- [blocks_float_to_short_0_5_0, '0', iio_device_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0, '1']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_1, out, iio_attr_sink_0_1, attr]
- [iio_attr_updater_0_1_0, out, iio_attr_sink_0_1_0, attr]
- [iio_attr_updater_0_1_0_0, out, iio_attr_sink_0_1_0_0, attr]
- [iio_attr_updater_0_1_0_0_0, out, iio_attr_sink_0_1_0_0_0, attr]
- [iio_attr_updater_0_1_0_1, out, iio_attr_sink_0_1_0_1, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
